# Keil uVision project Master_Telescope.uvproj, settings and files
target Master_Telescope (MCS-51)
  device: C8051F38C Silicon Labs
  cpu: IRAM(0-0xFF) XRAM(0x0000-0x07FF) IROM(0-0x3FFF) CLOCK(48000000)
  output: Master_Telescope
  c flags: SizeSpeed=1
  group Source
    ./: Master_Telescope V3.c
  group Librairies
    ./: Delay48M.LIB
target Simulations (MCS-51)
  device: C8051F38C Silicon Labs
  cpu: as above
  output: Master_Telescope
  c flags: SizeSpeed=1
