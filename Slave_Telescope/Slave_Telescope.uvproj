# Keil uVision project Slave_Telescope.uvproj, settings and files
target Slave Telescope (MCS-51)
  device: C8051F38C Silicon Labs
  cpu: IRAM(0-0xFF) XRAM(0x0000-0x07FF) IROM(0-0x3FFF) CLOCK(48000000)
  output: Slave_Telescope
  c flags: SizeSpeed=1
  group Source
    ./: Slave_Telescope.c
  group Librairies
    ./: Delay48M.LIB
target Simulation (MCS-51)
  device: C8051F38C Silicon Labs
  cpu: as above
  output: Slave_Telescope
  c flags: SizeSpeed=1
